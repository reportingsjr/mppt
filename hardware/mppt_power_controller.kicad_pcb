# Repository reportingsjr/mppt

File readme.md:

Embedded Systems 4038C Final Project
Solar Panel Maximum Power Point Tracker

## KiCad design hardware/mppt_power_controller.kicad_pcb

Parts:
C1, C2, C7, C9, C10, C12, C13, C19: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C8: 10uF,16V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 0.47uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C11, C14, C15, C17: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C18: 270uF,16V; CP_Elec_8x6.9
D1: YELLOW_LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: GREEN_LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D5: ORing Diode; D_SMB_Handsoldering
D4: D_SMB_Handsoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Solar Input; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J2: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J3: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD
J4: Battery; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J5: DISPLAY; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
L1: 10uH; L_Taiyo-Yuden_NR-80xx_HandSoldering
R1, R8: 0.01; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R9: 2; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R5: 1.5k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6, R7: 4.7k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R10, R11: 120k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R13: 330k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
TP1: Solar; TestPoint_Keystone_5019_Minature
TP2, TP7: GND; TestPoint_Keystone_5019_Minature
TP3: SDA; TestPoint_Keystone_5019_Minature
TP4: SCL; TestPoint_Keystone_5019_Minature
TP5: Buck_EN; TestPoint_Keystone_5019_Minature
TP6: 3.3V; TestPoint_Keystone_5019_Minature
TP8: Battery; TestPoint_Keystone_5019_Minature
U1, U4: INA233; VSSOP-10_3x3mm_P0.5mm
U2: LT3971; MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm
U3: ATSAMD21G18A-AUT; TQFP-48_7x7mm_P0.5mm
U5: AD5141; QFN-16-1EP_3x3mm_P0.5mm_EP1.45x1.45mm
U6: LT3080xST; SOT-223

Connections:
/3.3V: C1.1, C7.2, C9.2, C10.2, C11.1, C12.1, C14.1, C17.1, C19.1, J3.1 (VTref), J5.3, R4.1, R6.1, R7.1, TP6.1, U1.6, U3.6 (VDDANA), U3.17 (VDDIO), U3.36 (VDDIO), U3.44 (VDDIN), U4.2, U4.6, U5.7 (~RESET~), U5.8 (DIS), U5.9 (VDD), U5.10 (VLOGIC), U5.13 (~WP~), U5.16 (~LRDAC~), U6.2 (OUT), U6.4 (OUT)
/Buck_EN: TP5.1, U2.5 (EN), U3.16 (PA11)
/D+: J2.3 (D+), U3.34 (PA25)
/D-: J2.2 (D-), U3.33 (PA24)
/SCL: J5.2, R7.2, TP4.1, U1.5, U3.14 (PA09), U4.5, U5.11 (CLK/SCL)
/SDA: J5.1, R6.2, TP3.1, U1.4, U3.13 (PA08), U4.4, U5.12 (SDI/SDA)
/SWCLK: J3.4 (SWDCLK/TCK), R4.2, U3.45 (PA30)
/SWDIO: J3.2 (SWDIO/TMS), U3.46 (PA31)
/VBat: C13.1, D5.2 (A), J4.1, R8.1, TP8.1, U4.9
/Vusb: D3.2 (A), J2.1 (VBUS)
/~RESET: J3.10 (~RESET~), U3.40 (~RESET)
GND: C1.2, C3.2, C5.1, C7.1, C8.2, C9.1, C10.1, C11.2, C12.2, C14.2, C15.2, C17.2, C18.2, C19.2, D1.1 (K), D2.1 (K), D4.2 (A), J1.2, J2.5 (GND), J2.6 (Shield), J3.3 (GND), J3.5 (GND), J3.9 (GNDDetect), J4.2, J5.4, R10.2, R13.2, TP2.1, TP7.1, U1.1, U1.2, U1.7, U2.10 (SYNC), U2.11 (GND), U3.5 (GNDANA), U3.18 (GND), U3.35 (GND), U3.42 (GND), U4.1, U4.7, U5.1 (GND), U5.3 (W), U5.4 (B), U5.5 (VSS), U5.6 (~SYNC~/ADDR0), U5.14 (SDO/ADDR1), U5.15 (INDEP), U5.17 (PAD)
unnamed: C2.2, J1.1, R1.2, R2.2, TP1.1
unnamed: C4.1, U2.2 (BOOST)
unnamed: C4.2, D4.1 (K), L1.1, U2.3 (SW)
unnamed: C5.2, U3.43 (VDDCORE)
unnamed: C8.1, C13.2, L1.2, R8.2, R9.2, R11.1, U2.1 (BD)
unnamed: C15.1, D3.1 (K), D5.1 (K), U6.3 (IN)
unnamed: C2.1, C3.1, C18.1, R1.1, U1.9, U2.4 (VIN)
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R5.1
unnamed: R2.1, U1.8, U1.10
unnamed: R3.2, U3.2 (PA01)
unnamed: R5.2, U3.1 (PA00)
unnamed: R9.1, U4.8, U4.10
unnamed: R10.1, U2.8 (RT)
unnamed: R11.2, U2.6 (FB), U5.2 (A)
unnamed: R13.1, U6.1 (SET)

Notes on the sheet:
Solar Panel Input
~~20mA max on 3.3V rail for the micro, INA233s, and status LEDs.
board I/Os
Solar Panel Current/Voltage Monitor
Address 0b1000000 (0x40)
approx 400kHz switching freq
Battery Voltage/Current Monitor
Battery Output
Address 0b0101111 (0x2F)
Address 0b1000001 (0x41)
SERCOM2.0
SERCOM2.1
Microcontroller
VDDIO
VDDIN
VDDANA
VDDIO/VDDIN

Board: 4 copper layers, 50.0 x 50.0 mm, 58 parts (5 on the bottom side), 28 nets.

## Code that names these connections

File power_controller_firmware/driver_init.c:

/*
 * Code generated from Atmel Start.
 *
 * This file will be overwritten when reconfiguring your Atmel Start project.
 * Please copy examples or other code you want to keep to a separate file
 * to avoid losing it when reconfiguring.
 */

#include "driver_init.h"
#include <peripheral_clk_config.h>
#include <utils.h>
#include <hal_init.h>
#include <hpl_gclk_base.h>
#include <hpl_pm_base.h>

struct i2c_m_sync_desc I2C_0;

struct pwm_descriptor PWM_0;

void I2C_0_PORT_init(void)
{

	gpio_set_pin_pull_mode(PA08,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
	                       // <GPIO_PULL_UP"> Pull-up
	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(PA08, PINMUX_PA08D_SERCOM2_PAD0);

	gpio_set_pin_pull_mode(PA09,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
	                       // <GPIO_PULL_UP"> Pull-up
	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(PA09, PINMUX_PA09D_SERCOM2_PAD1);
}

void I2C_0_CLOCK_init(void)
{
	_pm_enable_bus_clock(PM_BUS_APBC, SERCOM2);
	_gclk_enable_channel(SERCOM2_GCLK_ID_CORE, CONF_GCLK_SERCOM2_CORE_SRC);
	_gclk_enable_channel(SERCOM2_GCLK_ID_SLOW, CONF_GCLK_SERCOM2_SLOW_SRC);
}

void I2C_0_init(void)
{
	I2C_0_CLOCK_init();
	i2c_m_sync_init(&I2C_0, SERCOM2);
	I2C_0_PORT_init();
}

void PWM_0_PORT_init(void)
{

	gpio_set_pin_function(PA10, PINMUX_PA10E_TCC1_WO0);
}

void PWM_0_CLOCK_init(void)
{
	_pm_enable_bus_clock(PM_BUS_APBC, TCC1);
	_gclk_enable_channel(TCC1_GCLK_ID, CONF_GCLK_TCC1_SRC);
}

void PWM_0_init(void)
{
	PWM_0_CLOCK_init();
	PWM_0_PORT_init();
	pwm_init(&PWM_0, TCC1, _tcc_get_pwm());
}

void system_init(void)
{
	init_mcu();

	// GPIO on PA00

	gpio_set_pin_level(GreenLED,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
	                   // <true"> High
	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(GreenLED, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(GreenLED, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA01

	gpio_set_pin_level(YellowLED,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
	                   // <true"> High
	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(YellowLED, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(YellowLED, GPIO_PIN_FUNCTION_OFF);

	gpio_set_pin_level(PA10, false);
	gpio_set_pin_direction(PA10, GPIO_DIRECTION_OUT);
	gpio_set_pin_function(PA10, GPIO_PIN_FUNCTION_OFF);

	gpio_set_pin_level(GPIO(GPIO_PORTA, 11), false);
	gpio_set_pin_direction(GPIO(GPIO_PORTA, 11), GPIO_DIRECTION_OUT);
	gpio_set_pin_function(GPIO(GPIO_PORTA, 11), GPIO_PIN_FUNCTION_OFF);

	//PWM_0_init();

	I2C_0_init();
}

## Commit log

2019-10-18 Create git repo
2019-10-18 Very rough start of MPPT design.
2019-10-20 Add KiCad specific .gitignore.
2019-10-20 Fix typo in KiCad filenames.
2019-10-20 Add LT3080 as 3.3V regulator, remove input/output solar and battery protection, add ARM JTAG connector, all symbols now have footprints.
2019-10-20 Remove backup file that should not have been committed.
2019-10-20 Wire up most of microcontroller, add some placeholder outputs, fix a small mistake on the TPS61090 boost controller.
2019-10-23 Add cache library to make project more portable
2019-10-24 Add PX3519 synchronous FET driver, a handful of testpoints, and clear ERC.
2019-10-24 Move yellow LED text that will not stop moving.
2019-10-24 Fix the footprints for a few components.
2019-10-24 Move footprints to general locations on the PCB and start with a 100mmx50mm board outline.
2019-10-24 Routed a good portion of the buck converter and the first voltage/current monitor.
2019-10-24 Add PDF of schematic
2019-10-24 Add four M3 mounting holes so I dont hate myself later.
2019-10-24 Put mounting holes 5mm in from board edge.
2019-10-24 Add some input capacitance for the solar panel
2019-10-25 Route a good amount of the microcontroller as well as the 5V power supply.
2019-10-30 Change INA233 from "rescue" library to real library. Small mistake!
2019-11-01 Move around 5V SMPS
2019-11-01 Add a test point for VBat. Route rest of power, I2C, test points, and everything else! Lots of cleanup needed from here to make the board look nice, but all of the nets have been routed.
2019-11-01 Remove test point reference designators. Also labelled some of the different circuits on the PCB.
2019-11-01 Flip solar panel connector around so pin 1 is power and pin 2 is ground like every other board with JST connectors.
2019-11-01 Version 1 gerbers added.
2019-11-07 Commit this tiny change to design notes so it isnt included in the next commit.
2019-11-08 Switch I2C pins from SERCOM0 which does not support I2C to SERCOM2. Schematic only, board has not been fixed.
2019-11-08 Add an atmel start configuration file
2019-11-20 Update design notes a bit and add the hex addresses of the power monitors to the schematic.
2019-11-20 Add amazing interactive bom for assembly
2019-11-20 Add ASF4 reference manual and SAMD21 errata.
2019-11-20 Remove bad atmel start config
2019-11-20 Remove atmel start files that were not supposed to be commited.
2019-11-20 This commit adds a large amount of code from atmel start. Much of it is very boiler plate and inefficient, but it works!
    This boots the micro with an internal 8MHz oscillator as the core clock.
    A 50kHz PWM signal is output as well as an enable signal for the FET
    controller.
    This also reads voltages from both of the power monitoring ICs.
    Very messy at this point, but this is a good base.
2019-11-20 Add a script to convert an Atmel Studio 7 windows makefile to a linux version.
2019-11-20 Change makefile modifier to an executable.
2019-11-20 Fully remove old atmel start config
2019-11-20 Updated gitignore to ignore files from building power electronics firmware.
2019-11-21 Create source and header file for INA233 library.
2019-11-21 wrong include?
2019-11-21 Fill out INA233 library a bit more.
2019-11-21 Fix a couple small mistakes
2019-11-21 This setup is awful. Commit elf file for testing.
2019-11-21 Accidentally left shifted 2 instead of 1
2019-11-21 Modify get_current function to use I2C transfer in a different manner. The INA233 may not be responding with the current because the calibration register isn't being written. I think this is because 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
    See page 19 (Writing to and Reading From the INA233) to see what it expects
    for writing to a register.
2019-11-21 fix error?
2019-11-21 update elf
2019-11-21 Fix bug where get_current was returning zero even though it received the correct values over I2C.
    Replace the test I2C register write code with two functions to handle doing that more cleanly.
2019-11-21 separate return values for debugging purposes
2019-11-21 Debugging this float calculation
2019-11-21 gcc, please stop optimizing my variables out for a minute
2019-11-21 Oh, bit shift operators have lower precedence than addition.
2019-11-21 Add a function to convert from signed 2s complement in to signed decimal format.
2019-11-21 Oops.
2019-11-21 Fix bit comparison
2019-11-21 bitten by operator precedence again
2019-11-21 Added a function to update the INA233 ADC config as well as a bunch of defines for this function.
2019-12-03 Add an IV curve image of the solar cell and an image of the schematic.
2019-12-03 Implement perturb and observe algorithm
2019-12-03 Fix small typo
2020-04-10 Add some new datasheets, modify code to only flash LEDs as a starting point.
2020-04-17 Add SSD1306 OLED display driver. Set up main.c to display input and output voltage/current on the display.
